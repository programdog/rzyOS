# Keil uVision project rzyOS.uvprojx, settings and files
target rzyOS_F4_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rzyOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\arch\arm\STM32F4xx_StdPeriph_Driver\FWLIB\inc;..\..\arch\arm\STM32F4xx_StdPeriph_Driver\CMSIS;..\..\arch\chip\STM32F4xx_StdPeriph_Templates;..\..\rzyOS_kernel;..\..\src\board\stm32f4discovery\app;..\..\src\board\stm32f4discovery\drvice\LED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group rzyOS_kernel
    ../../rzyOS_kernel/: rzyOS_bitmap.c rzyOS_delay.c rzyOS_event.c rzyOS_eventgroup.c rzyOS_hook.c rzyOS_list.c rzyOS_mbox.c rzyOS_memory.c rzyOS_mutex.c rzyOS_schedule.c rzyOS_semaphore.c rzyOS_switch.c rzyOS_task.c rzyOS_wqueue.c
  group user
    ../../arch/chip/STM32F4xx_StdPeriph_Templates/: stm32f4xx_it.c system_stm32f4xx.c
    ../../src/board/stm32f4discovery/app/: main.c
  group FWLIB
    ../../arch/arm/STM32F4xx_StdPeriph_Driver/FWLIB/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group hardware
    ../../src/board/stm32f4discovery/drvice/LED/: led.c
  group startup
    ../../arch/arm/STM32F4xx_StdPeriph_Driver/startup/arm/: startup_stm32f40_41xxx.s
